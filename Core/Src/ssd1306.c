/* ssd1306.c: driver mínimo próprio do OLED 128x64 (I2C1, 0x3C), fonte 6x8.
 * Parte original: Nicolas (FW7).
 * Framebuffer único e estático de 1024 bytes (8 páginas x 128 colunas).
 * Cada página vai numa só transação I2C (~12 ms a 100 kHz), com timeout
 * OLED_TIMEOUT_MS; em erro chama i2c1_recupera() e devolve 0. */
#include "ssd1306.h"
#include "i2c.h"
#include "config.h"
#include "ina219.h"

#define LARG        128u
#define PAGINAS     8u
#define CAR_LARG    6u      /* 5 colunas da fonte + 1 de espaço */

static uint8_t fb[PAGINAS][LARG];

/* Fonte 5x7 clássica, 0x20..0x7E, 5 colunas por caractere (bit 0 = topo). */
static const uint8_t fonte[95][5] = {
    {0x00,0x00,0x00,0x00,0x00}, {0x00,0x00,0x5F,0x00,0x00}, /*  ! */
    {0x00,0x07,0x00,0x07,0x00}, {0x14,0x7F,0x14,0x7F,0x14}, /* " # */
    {0x24,0x2A,0x7F,0x2A,0x12}, {0x23,0x13,0x08,0x64,0x62}, /* $ % */
    {0x36,0x49,0x55,0x22,0x50}, {0x00,0x05,0x03,0x00,0x00}, /* & ' */
    {0x00,0x1C,0x22,0x41,0x00}, {0x00,0x41,0x22,0x1C,0x00}, /* ( ) */
    {0x14,0x08,0x3E,0x08,0x14}, {0x08,0x08,0x3E,0x08,0x08}, /* * + */
    {0x00,0x50,0x30,0x00,0x00}, {0x08,0x08,0x08,0x08,0x08}, /* , - */
    {0x00,0x60,0x60,0x00,0x00}, {0x20,0x10,0x08,0x04,0x02}, /* . / */
    {0x3E,0x51,0x49,0x45,0x3E}, {0x00,0x42,0x7F,0x40,0x00}, /* 0 1 */
    {0x42,0x61,0x51,0x49,0x46}, {0x21,0x41,0x45,0x4B,0x31}, /* 2 3 */
    {0x18,0x14,0x12,0x7F,0x10}, {0x27,0x45,0x45,0x45,0x39}, /* 4 5 */
    {0x3C,0x4A,0x49,0x49,0x30}, {0x01,0x71,0x09,0x05,0x03}, /* 6 7 */
    {0x36,0x49,0x49,0x49,0x36}, {0x06,0x49,0x49,0x29,0x1E}, /* 8 9 */
    {0x00,0x36,0x36,0x00,0x00}, {0x00,0x56,0x36,0x00,0x00}, /* : ; */
    {0x08,0x14,0x22,0x41,0x00}, {0x14,0x14,0x14,0x14,0x14}, /* < = */
    {0x00,0x41,0x22,0x14,0x08}, {0x02,0x01,0x51,0x09,0x06}, /* > ? */
    {0x32,0x49,0x79,0x41,0x3E}, {0x7E,0x11,0x11,0x11,0x7E}, /* @ A */
    {0x7F,0x49,0x49,0x49,0x36}, {0x3E,0x41,0x41,0x41,0x22}, /* B C */
    {0x7F,0x41,0x41,0x22,0x1C}, {0x7F,0x49,0x49,0x49,0x41}, /* D E */
    {0x7F,0x09,0x09,0x09,0x01}, {0x3E,0x41,0x49,0x49,0x7A}, /* F G */
    {0x7F,0x08,0x08,0x08,0x7F}, {0x00,0x41,0x7F,0x41,0x00}, /* H I */
    {0x20,0x40,0x41,0x3F,0x01}, {0x7F,0x08,0x14,0x22,0x41}, /* J K */
    {0x7F,0x40,0x40,0x40,0x40}, {0x7F,0x02,0x0C,0x02,0x7F}, /* L M */
    {0x7F,0x04,0x08,0x10,0x7F}, {0x3E,0x41,0x41,0x41,0x3E}, /* N O */
    {0x7F,0x09,0x09,0x09,0x06}, {0x3E,0x41,0x51,0x21,0x5E}, /* P Q */
    {0x7F,0x09,0x19,0x29,0x46}, {0x46,0x49,0x49,0x49,0x31}, /* R S */
    {0x01,0x01,0x7F,0x01,0x01}, {0x3F,0x40,0x40,0x40,0x3F}, /* T U */
    {0x1F,0x20,0x40,0x20,0x1F}, {0x3F,0x40,0x38,0x40,0x3F}, /* V W */
    {0x63,0x14,0x08,0x14,0x63}, {0x07,0x08,0x70,0x08,0x07}, /* X Y */
    {0x61,0x51,0x49,0x45,0x43}, {0x00,0x7F,0x41,0x41,0x00}, /* Z [ */
    {0x02,0x04,0x08,0x10,0x20}, {0x00,0x41,0x41,0x7F,0x00}, /* \ ] */
    {0x04,0x02,0x01,0x02,0x04}, {0x40,0x40,0x40,0x40,0x40}, /* ^ _ */
    {0x00,0x01,0x02,0x04,0x00}, {0x20,0x54,0x54,0x54,0x78}, /* ` a */
    {0x7F,0x48,0x44,0x44,0x38}, {0x38,0x44,0x44,0x44,0x20}, /* b c */
    {0x38,0x44,0x44,0x48,0x7F}, {0x38,0x54,0x54,0x54,0x18}, /* d e */
    {0x08,0x7E,0x09,0x01,0x02}, {0x0C,0x52,0x52,0x52,0x3E}, /* f g */
    {0x7F,0x08,0x04,0x04,0x78}, {0x00,0x44,0x7D,0x40,0x00}, /* h i */
    {0x20,0x40,0x44,0x3D,0x00}, {0x7F,0x10,0x28,0x44,0x00}, /* j k */
    {0x00,0x41,0x7F,0x40,0x00}, {0x7C,0x04,0x18,0x04,0x78}, /* l m */
    {0x7C,0x08,0x04,0x04,0x78}, {0x38,0x44,0x44,0x44,0x38}, /* n o */
    {0x7C,0x14,0x14,0x14,0x08}, {0x08,0x14,0x14,0x18,0x7C}, /* p q */
    {0x7C,0x08,0x04,0x04,0x08}, {0x48,0x54,0x54,0x54,0x20}, /* r s */
    {0x04,0x3F,0x44,0x40,0x20}, {0x3C,0x40,0x40,0x20,0x7C}, /* t u */
    {0x1C,0x20,0x40,0x20,0x1C}, {0x3C,0x40,0x30,0x40,0x3C}, /* v w */
    {0x44,0x28,0x10,0x28,0x44}, {0x0C,0x50,0x50,0x50,0x3C}, /* x y */
    {0x44,0x64,0x54,0x4C,0x44}, {0x00,0x08,0x36,0x41,0x00}, /* z { */
    {0x00,0x00,0x7F,0x00,0x00}, {0x00,0x41,0x36,0x08,0x00}, /* | } */
    {0x10,0x08,0x08,0x10,0x08}                              /* ~ */
};

/* Sequência de init (modo de endereçamento por página). */
static const uint8_t seq_init[] = {
    0x00,               /* prefixo: o resto são comandos */
    0xAE,               /* display off */
    0xD5, 0x80,         /* clock */
    0xA8, 0x3F,         /* multiplex 1/64 */
    0xD3, 0x00,         /* deslocamento 0 */
    0x40,               /* linha inicial 0 */
    0x8D, 0x14,         /* bomba de carga ligada */
    0x20, 0x02,         /* endereçamento por página */
    0xA1,               /* segmento invertido */
    0xC8,               /* varredura invertida */
    0xDA, 0x12,         /* pinos COM */
    0x81, 0xCF,         /* contraste */
    0xD9, 0xF1,         /* pré-carga */
    0xDB, 0x40,         /* nível VCOMH */
    0xA4,               /* segue o RAM */
    0xA6,               /* normal (não invertido) */
    0xAF                /* display on */
};

/* Uma transação I2C; em erro tenta recuperar o barramento. */
static uint8_t tx(uint8_t *d, uint16_t n)
{
    if (HAL_I2C_Master_Transmit(&hi2c1, OLED_ADDR, d, n, OLED_TIMEOUT_MS) == HAL_OK) {
        return 1u;
    }
    i2c1_recupera();
    return 0u;
}

uint8_t ssd1306_init(void)
{
    uint8_t cmd[sizeof(seq_init)];
    uint8_t i;

    HAL_Delay(100);                         /* o OLED precisa de tempo após energizar */
    for (i = 0u; i < sizeof(seq_init); i++) {
        cmd[i] = seq_init[i];
    }
    if (!tx(cmd, (uint16_t)sizeof(cmd))) {
        return 0u;
    }
    ssd1306_limpa();
    return ssd1306_envia();
}

void ssd1306_limpa(void)
{
    uint8_t p, c;

    for (p = 0u; p < PAGINAS; p++) {
        for (c = 0u; c < LARG; c++) {
            fb[p][c] = 0u;
        }
    }
}

void ssd1306_pixel(uint8_t x, uint8_t y)
{
    if (x < LARG && y < (PAGINAS * 8u)) {
        fb[y >> 3][x] |= (uint8_t)(1u << (y & 7u));
    }
}

void ssd1306_texto(uint8_t col, uint8_t lin, const char *s)
{
    if (lin >= PAGINAS || s == 0) {
        return;
    }
    while (*s != '\0' && (uint16_t)col + CAR_LARG <= LARG) {
        uint8_t c = (uint8_t)*s++;
        const uint8_t *g;
        uint8_t k;

        if (c < 0x20u || c > 0x7Eu) {
            c = (uint8_t)'?';
        }
        g = fonte[c - 0x20u];
        for (k = 0u; k < 5u; k++) {
            fb[lin][col + k] = g[k];
        }
        fb[lin][col + 5u] = 0u;             /* coluna de espaço */
        col = (uint8_t)(col + CAR_LARG);
    }
}

uint8_t ssd1306_envia_pagina(uint8_t pagina)
{
    uint8_t buf[7u + LARG];
    uint8_t c;

    if (pagina >= PAGINAS) {
        return 0u;
    }
    buf[0] = 0x80u; buf[1] = (uint8_t)(0xB0u + pagina);   /* página */
    buf[2] = 0x80u; buf[3] = 0x00u;                       /* coluna baixa 0 */
    buf[4] = 0x80u; buf[5] = 0x10u;                       /* coluna alta 0 */
    buf[6] = 0x40u;                                       /* dados */
    for (c = 0u; c < LARG; c++) {
        buf[7u + c] = fb[pagina][c];
    }
    return tx(buf, (uint16_t)sizeof(buf));
}

uint8_t ssd1306_envia(void)
{
    uint8_t p;

    for (p = 0u; p < PAGINAS; p++) {
        if (!ssd1306_envia_pagina(p)) {
            return 0u;                      /* para na primeira falha */
        }
    }
    return 1u;
}
